# Keil uVision project BallBot_V1.uvprojx, settings and files
target BallBot_V1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BallBot_V1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\..\firmware;..\Include;..\STM32F4xx_StdPeriph_Driver\inc;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../: main.c stm32f4xx_it.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_gpio.c
  group Source
    ../Source/: Button.c MotorControl.c
